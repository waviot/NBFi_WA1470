#include <stdlib.h>
#include <stdint.h>
#include <string.h>
#include <stdio.h>

const uint8_t PCODE_indexes[160] = {
		31, 47, 55, 57, 58, 59, 60, 61, 62, 63, 78, 79, 83, 85, 86, 87,
		89, 90, 91, 92, 93, 94, 95, 99, 101, 102, 103, 105, 106, 107, 108, 109,
		110, 111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 125,
		126, 127, 135, 139, 141, 142, 143, 147, 149, 150, 151, 152, 153, 154, 155, 156,
		157, 158, 159, 162, 163, 164, 165, 166, 167, 168, 169, 170, 171, 172, 173, 174,
		175, 176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 190,
		191, 193, 194, 195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 207,
		208, 209, 210, 211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 221, 222, 223,
		224, 225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 239,
		240, 241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 255
};

void PCODE_encode(uint8_t power, uint8_t* in, uint8_t* out){

    uint8_t data_20_i = 0;
    uint8_t data_20_sum[20];
    uint8_t t;

    uint32_t  sl;

    for (int i=0; i<20; i++){
    	data_20_sum[i] = 0;
    	for (int j=0;j<8;j++){
    		data_20_sum[i] += (((in[i]>>(7-j) )& 1) * (1<<(7 - j)));
    		data_20_i+= 1;
    	}
    }

    for (int i=0; i<32; i++)
    	out[i] = 0;

    for (int i=0; i<160; i++){
        t = (data_20_sum[i/8] >> (7-(i%8))) & 1;

        out[PCODE_indexes[i]/8] |= t << (7 - PCODE_indexes[i] % 8);

    }
    for (int i=0; i < 32; i++){
        out[i] = out[i] ^ ((out[i] & 0x55) << 1);
        out[i] = out[i] ^ ((out[i] & 0x33) << 2);
        out[i] = out[i] ^ ((out[i] & 0x0F) << 4);
    }

    for (uint8_t i = 3; i < power; i++){
        sl = (1 << (i - 2));
        uint32_t temp = (1 << (power - 3)) / sl;
        for (uint32_t j=0; j < temp; j++){
            for (uint32_t t = j*sl; t < j*sl+sl/2; t++){
                out[t] = out[t] ^ out[t + sl/2];
            }
        }
	}
}
