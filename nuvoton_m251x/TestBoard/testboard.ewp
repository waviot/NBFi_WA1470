# IAR project testboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M251AE series Nuvoton M251AE series (M251,M252,M254,M256,M258)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: WA1471
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: Inc; ..\..\NBFiLib\wa1470\wa1470; ..\..\NBFiLib\nbfi; ..\..\NBFiLib\gost_crypto\crypto; ..\..\NBFiLib\preambula\preambula; ..\..\NBFiLib\scheduler\scheduler; ..\..\NBFiLib\nbfi_at_server; NBFiHAL; Library\StdDriver\inc; Library\Device\Nuvoton\M251\Include; Library\CMSIS\Include; ..\..\NBFiLib\wa1471
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testboard.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: Src\m251.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  ICCARM.CCDefines: USE_V85XX_DRIVER; __V85XX_EWARM_USED
  ICCARM.CCIncludePath2: ..\Src; ..\Inc; ..\..\..\Libraries\V85XX_Driver\inc; ..\..\..\Libraries\V85XX_Driver\src; ..\..\..\Libraries\CMSIS\device; ..\..\..\Libraries\CMSIS\include
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: v85xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    Library/Device/Nuvoton/M251/Source/IAR/: startup_M251.s
    Library/Device/Nuvoton/M251/Source/: system_M251.c
  group Library
    Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c timer.c uart.c
  group NBFiHAL
    NBFiHAL/: nbfi_hal.c nbfi_hal.h radio.c radio.h scheduler_hal.c scheduler_hal.h wa147x_hal.c wa147x_hal.h
  group NBFiLib/magma
    ../../NBFiLib/gost_crypto/crypto/: magma.c magma.h
  group NBFiLib/nbfi
    ../../NBFiLib/nbfi/: nbfi.c nbfi.h nbfi_config.c nbfi_config.h nbfi_crc.c nbfi_crc.h nbfi_crypto.c nbfi_crypto.h nbfi_defines.h nbfi_mac.c nbfi_mac.h nbfi_rf.c nbfi_rf.h nbfi_transport.c nbfi_transport.h nbfi_transport_misc.c nbfi_transport_misc.h nbfi_types.h pcode.c pcode.h zcode.c zcode.h
  group NBFiLib/nbfi_at_server
    ../../NBFiLib/nbfi_at_server/: nbfi_at_server.c nbfi_at_server.h nbfi_at_server_handlers.c nbfi_at_server_handlers.h nbfi_at_server_tags.c nbfi_at_server_tags.h nbfi_at_server_types.h
  group NBFiLib/preambula
    ../../NBFiLib/preambula/preambula/: preambula.c preambula.h
  group NBFiLib/scheduler
    ../../NBFiLib/scheduler/scheduler/: ischeduler.h scheduler.c scheduler.h
  group NBFiLib/scheduler/libmf
    ../../NBFiLib/scheduler/scheduler/libmf/: libmfwtimer.h wt0.c wt01.c wtimer.c wtimer.h
  group NBFiLib/scheduler/watimer
    ../../NBFiLib/scheduler/scheduler/watimer/: watimer.c watimer.h
  group NBFiLib/wa1470
    ../../NBFiLib/wa1470/wa1470/: wa1470.c wa1470.h wa1470_defines.h wa1470dem.c wa1470dem.h wa1470mod.c wa1470mod.h wa1470mod_bpsk_pin.c wa1470rfe.c wa1470rfe.h
  group NBFiLib/wa1471
    ../../NBFiLib/wa1471/: wa1471.c wa1471.h wa1471_defines.h wa1471dem.c wa1471dem.h wa1471mod.c wa1471mod.h wa1471mod_bpsk_pin.c wa1471rfe.c wa1471rfe.h
  group src
    Src/: main.c
