# IAR project sample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071CZ ST STM32L071CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L071xx
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: Inc; Drivers\STM32L0xx_HAL_Driver\Inc; Drivers\CMSIS\Device\ST\STM32L0xx\Include; Drivers\CMSIS\Include; ..\NBFiLib\wa1470; ..\NBFiLib\libmf; ..\NBFiLib\misc; ..\NBFiLib\nbfi; Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\NBFiLib\gost_crypto\crypto; ..\NBFiLib\preambula\preambula
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.hex
  ILINK.IlinkOutputFile: sample.out
  ILINK.IlinkIcfFile: Src\stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group drivers/cmsis/device/st/STM32L0xx/include
    Drivers/CMSIS/Device/ST/STM32L0xx/Include/: stm32l071xx.h stm32l0xx.h system_stm32l0xx.h
  group drivers/cmsis/include
    Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group drivers/STM32L0xx_HAL_Driver/inc
    Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_cortex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart.h stm32l0xx_hal_usart_ex.h
  group drivers/STM32L0xx_HAL_Driver/inc/legacy
    Drivers/STM32L0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group drivers/STM32L0xx_HAL_Driver/src
    Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group NBFiLib/inc
    Inc/: main.h radio.h rs485_uart.h stm32_init.h stm32l0xx_hal_conf.h stm32l0xx_it.h xbuf.h
  group NBFiLib/libmf
    ../NBFiLib/libmf/: wt0.c wt01.c wtimer.c wtimer.h
  group NBFiLib/misc
    ../NBFiLib/misc/: log.c log.h zcode.c zcode.h
    ../NBFiLib/gost_crypto/crypto/: magma.c magma.h
    ../NBFiLib/preambula/preambula/: preambula.c preambula.h
  group NBFiLib/nbfi
    ../NBFiLib/nbfi/: nbfi.c nbfi.h nbfi_config.c nbfi_config.h nbfi_crypto.c nbfi_crypto.h nbfi_defines.h nbfi_mac.c nbfi_mac.h nbfi_misc.c nbfi_misc.h nbfi_rf.c nbfi_rf.h
  group NBFiLib/wa1470
    ../NBFiLib/wa1470/: wa1470.c wa1470.h wa1470dem.c wa1470dem.h wa1470mod.c wa1470mod.h wa1470mod_bpsk_pin.c wa1470rfe.c wa1470rfe.h
  group src
    Src/: main.c radio.c rs485_uart.c stm32_init.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c xbuf.c
  group startup
    startup/: startup_stm32l071xx.s
