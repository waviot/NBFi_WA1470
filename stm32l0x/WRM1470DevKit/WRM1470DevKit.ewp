# IAR project WRM1470DevKit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071KB ST STM32L071KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L071xx
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: Inc; Drivers\STM32L0xx_HAL_Driver\Inc; Drivers\CMSIS\Device\ST\STM32L0xx\Include; Drivers\CMSIS\Include; ..\..\NBFiLib\wa1470\wa1470; ..\..\NBFiLib\nbfi; Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\NBFiLib\gost_crypto\crypto; ..\..\NBFiLib\preambula\preambula; NBFiHAL; ..\..\NBFiLib\scheduler\scheduler; ..\..\NBFiLib\nbfi_at_server; GUI; ..\..\stm32-ssd1306\ssd1306; ..\..\stm32-ssd1306\examples\oled-tester\firmware\i2c\ssd1306
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WRM1470DevKit.hex
  ILINK.IlinkOutputFile: WRM1470DevKit.out
  ILINK.IlinkIcfFile: Src\stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group drivers/cmsis/device/st/STM32L0xx/include
    Drivers/CMSIS/Device/ST/STM32L0xx/Include/: stm32l071xx.h stm32l0xx.h system_stm32l0xx.h
  group drivers/cmsis/include
    Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group drivers/STM32L0xx_HAL_Driver/inc
    Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.h stm32l0xx_hal_cortex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_rtc.h stm32l0xx_hal_rtc_ex.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart.h stm32l0xx_hal_usart_ex.h stm32l0xx_ll_adc.h
  group drivers/STM32L0xx_HAL_Driver/inc/legacy
    Drivers/STM32L0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group drivers/STM32L0xx_HAL_Driver/src
    Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_ll_adc.c
  group GUI
    GUI/: buttons.c buttons.h fonts.c fonts.h glcd.c glcd.h gui.c gui.h stlcd.c stlcd.h time.c time.h
  group GUI/ssd1306
    ../../stm32-ssd1306/ssd1306/: ssd1306.c ssd1306.h ssd1306_conf_template.h ssd1306_fonts.c ssd1306_fonts.h ssd1306_tests.c ssd1306_tests.h
    ../../stm32-ssd1306/examples/oled-tester/firmware/i2c/ssd1306/: ssd1306_conf.h
  group inc
    Inc/: adc.h at_user.h defines.h log.h main.h plot_spectrum.h rs485_uart.h rtc.h stm32_init.h stm32l0xx_hal_conf.h stm32l0xx_it.h xbuf.h
  group NBFiHAL
    NBFiHAL/: nbfi_hal.c nbfi_hal.h radio.c radio.h scheduler_hal.c scheduler_hal.h wa1470_hal.c wa1470_hal.h
  group NBFiLib/magma
    ../../NBFiLib/gost_crypto/crypto/: magma.c magma.h
  group NBFiLib/nbfi
    ../../NBFiLib/nbfi/: nbfi.c nbfi.h nbfi_config.c nbfi_config.h nbfi_crc.c nbfi_crc.h nbfi_crypto.c nbfi_crypto.h nbfi_defines.h nbfi_mac.c nbfi_mac.h nbfi_rf.c nbfi_rf.h nbfi_transport.c nbfi_transport.h nbfi_transport_misc.c nbfi_transport_misc.h nbfi_types.h pcode.c pcode.h zcode.c zcode.h
  group NBFiLib/nbfi_at_server
    ../../NBFiLib/nbfi_at_server/: nbfi_at_server.c nbfi_at_server.h nbfi_at_server_handlers.c nbfi_at_server_handlers.h nbfi_at_server_tags.c nbfi_at_server_tags.h nbfi_at_server_types.h
  group NBFiLib/preambula
    ../../NBFiLib/preambula/preambula/: preambula.c preambula.h
  group NBFiLib/scheduler
    ../../NBFiLib/scheduler/scheduler/: ischeduler.h scheduler.c scheduler.h
  group NBFiLib/scheduler/libmf
    ../../NBFiLib/scheduler/scheduler/libmf/: libmfwtimer.h wt0.c wt01.c wtimer.c wtimer.h
  group NBFiLib/scheduler/watimer
    ../../NBFiLib/scheduler/scheduler/watimer/: watimer.c watimer.h
  group NBFiLib/wa1470
    ../../NBFiLib/wa1470/wa1470/: wa1470.c wa1470.h wa1470_defines.h wa1470dem.c wa1470dem.h wa1470mod.c wa1470mod.h wa1470mod_bpsk_pin.c wa1470rfe.c wa1470rfe.h
  group src
    Src/: adc.c at_user.c log.c main.c plot_spectrum.c rs485_uart.c rtc.c stm32_init.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c xbuf.c
  group startup
    startup/: startup_stm32l071xx.s
