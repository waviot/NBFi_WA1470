<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32L412k8u.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\STM32L412k8u_boot.ewp</path>
    </project>
    <batchBuild />
</workspace>
