# IAR project STM32L412k8u.ewp, settings and files
configuration STM32L412k8u (ARM, debug)
  General.OGChipSelectEditMenu: STM32L412KB ST STM32L412KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L412xx; DEBUG; ARM_MATH_CM4; USE_RTC_WATIMER; _DLIB_TIME_USES_64; __STDC_WANT_LIB_EXT1__; USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; MSI_VALUE=16000000
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Inc\WVT; ..\Inc\NBFiHAL; ..\Inc\shared; ..\..\NBFiLib\gost_crypto\crypto; ..\..\NBFiLib\nbfi; ..\..\NBFiLib\preambula\preambula; ..\..\NBFiLib\scheduler\scheduler; ..\..\NBFiLib\wa1470\wa1470; ..\..\NBFiLib\scheduler\scheduler\libmf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32L412k8u.hex
  ILINK.IlinkOutputFile: STM32L412k8u.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l412xx.s
  group Application/User
    ../Src/: adc.c crc.c dma.c gpio.c iwdg.c main.c rtc.c spi.c stm32l4xx_it.c tim.c usart.c
  group Application/User/Libs
    ../../NBFiLib/gost_crypto/crypto/: magma.c
    ../../NBFiLib/preambula/preambula/: preambula.c
    ../../NBFiLib/scheduler/scheduler/: scheduler.c
    ../../NBFiLib/scheduler/scheduler/watimer/: watimer.c
  group Application/User/Libs/nbfi
    ../../NBFiLib/nbfi/: nbfi.c nbfi_config.c nbfi_crc.c nbfi_crypto.c nbfi_mac.c nbfi_rf.c nbfi_transport.c nbfi_transport_misc.c pcode.c zcode.c
  group Application/User/Libs/wa1470
    ../../NBFiLib/wa1470/wa1470/: wa1470.c wa1470dem.c wa1470mod.c wa1470mod_bpsk_pin.c wa1470rfe.c
  group Application/User/NBFiHAL
    ../Src/NBFiHAL/: nbfi_hal.c radio.c scheduler_hal.c wa1470_hal.c
  group Application/User/shared
    ../Src/shared/: update.c
  group Application/User/WVT
    ../Src/WVT/: cb.c meter.c water7.c WVT_Button.c WVT_EEPROM.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_adc.c stm32l4xx_ll_crc.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
