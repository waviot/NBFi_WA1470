# IAR project testboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XX VANGO V85XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_TARGET_DRIVER
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: Inc; Drivers\Lib_Driver\inc; Drivers\CMSIS\CMSIS_Include; Drivers\CMSIS\include; ..\..\NBFiLib\wa1470\wa1470; ..\..\NBFiLib\nbfi; ..\..\NBFiLib\gost_crypto\crypto; ..\..\NBFiLib\preambula\preambula; ..\..\NBFiLib\scheduler\scheduler; ..\..\NBFiLib\nbfi_at_server; NBFiHAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testboard.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: Src\target_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_V85XX_DRIVER; __V85XX_EWARM_USED
  ICCARM.CCIncludePath2: ..\Src; ..\Inc; ..\..\..\Libraries\V85XX_Driver\inc; ..\..\..\Libraries\V85XX_Driver\src; ..\..\..\Libraries\CMSIS\device; ..\..\..\Libraries\CMSIS\include
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: v85xx_flash.icf
  group Drivers
    Drivers/Lib_Driver/src/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_comp.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c
  group Drivers/Device
    Drivers/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
  group inc
    Inc/: lib_conf.h main.h target_isr.h v_stdio.h
  group NBFiHAL
    NBFiHAL/: nbfi_hal.c nbfi_hal.h radio.c radio.h scheduler_hal.c scheduler_hal.h wa1470_hal.c wa1470_hal.h
  group NBFiLib/magma
    ../../NBFiLib/gost_crypto/crypto/: magma.c magma.h
  group NBFiLib/nbfi
    ../../NBFiLib/nbfi/: nbfi.c nbfi.h nbfi_config.c nbfi_config.h nbfi_crc.c nbfi_crc.h nbfi_crypto.c nbfi_crypto.h nbfi_defines.h nbfi_mac.c nbfi_mac.h nbfi_rf.c nbfi_rf.h nbfi_transport.c nbfi_transport.h nbfi_transport_misc.c nbfi_transport_misc.h nbfi_types.h pcode.c pcode.h zcode.c zcode.h
  group NBFiLib/nbfi_at_server
    ../../NBFiLib/nbfi_at_server/: nbfi_at_server.c nbfi_at_server.h nbfi_at_server_handlers.c nbfi_at_server_handlers.h nbfi_at_server_tags.c nbfi_at_server_tags.h nbfi_at_server_types.h
  group NBFiLib/preambula
    ../../NBFiLib/preambula/preambula/: preambula.c preambula.h
  group NBFiLib/scheduler
    ../../NBFiLib/scheduler/scheduler/: ischeduler.h scheduler.c scheduler.h
  group NBFiLib/scheduler/libmf
    ../../NBFiLib/scheduler/scheduler/libmf/: libmfwtimer.h wt0.c wt01.c wtimer.c wtimer.h
  group NBFiLib/scheduler/watimer
    ../../NBFiLib/scheduler/scheduler/watimer/: watimer.c watimer.h
  group NBFiLib/wa1470
    ../../NBFiLib/wa1470/wa1470/: wa1470.c wa1470.h wa1470_defines.h wa1470dem.c wa1470dem.h wa1470mod.c wa1470mod.h wa1470mod_bpsk_pin.c wa1470rfe.c wa1470rfe.h
  group src
    Src/: main.c target_isr.c v_stdio.c
  group startup
    startup/: startup_target.s
